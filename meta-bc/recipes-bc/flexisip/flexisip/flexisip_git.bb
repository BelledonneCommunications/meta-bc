require flexisip.inc

SRCREV = "dd02e9e2a386178f1976259954b9ce7ba9f7118a"
SRC_URI = "git://git.linphone.org/flexisip.git"
PV = "git_${SRCREV}"

LIC_FILES_CHKSUM = "file://COPYING;md5=50dcff91f43ed602118e107ad4dccb65"
