require ortp.inc

SRCREV = "7170e5c6242b305114c681940ec78260847122ff"
SRC_URI = "git://git.linphone.org/ortp.git"
PV = "git_${SRCREV}"

LIC_FILES_CHKSUM = "file://COPYING;md5=7fbc338309ac38fefcd64b04bb903e34"
