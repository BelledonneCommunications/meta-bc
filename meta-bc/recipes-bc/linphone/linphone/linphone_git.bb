require linphone.inc

SRCREV = "77df52a71ad060c7995221e097dc32deddfc57c1"
SRC_URI = "gitsm://git.linphone.org/linphone.git"
PV = "git_${SRCREV}"

LIC_FILES_CHKSUM = "file://COPYING;md5=d0df6696dd1de18b107a24dc34735b28"
