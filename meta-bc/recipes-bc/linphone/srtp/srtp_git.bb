require srtp.inc

SRCREV = "37448b2aebeb5e9bd2d39d3a82f0721123cdd4a2"
SRC_URI = "git://git.linphone.org/srtp.git"
PV = "git_${SRCREV}"

LIC_FILES_CHKSUM = "file://LICENSE;md5=15bc16b9d2e305974dde47e733883714"
