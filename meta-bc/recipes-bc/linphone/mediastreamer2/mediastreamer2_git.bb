require mediastreamer2.inc

SRCREV = "f0934dd80bee2f761a169c9c27bd4c9c3fda22c4"
SRC_URI = "git://git.linphone.org/mediastreamer2.git"
PV = "git_${SRCREV}"

LIC_FILES_CHKSUM = "file://COPYING;md5=c46082167a314d785d012a244748d803"
