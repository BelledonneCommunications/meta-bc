require polarssl.inc

SRCREV = "cecb44e4f13f42f793dde34b42793e1ebcce91a5"
SRC_URI = "git://git.linphone.org/polarssl.git;nobranch=1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=751419260aa954499f7abaabaa882bbe;rev={SRCREV}"