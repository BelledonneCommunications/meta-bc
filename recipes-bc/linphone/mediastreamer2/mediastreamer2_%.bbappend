FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"

SRC_URI += " file://mediastreamer2_cmakefile.patch"