require cunit.inc

PR = "${INC_PR}.0"

SRCREV = "6ce00eae4ca20ab284e17a88d8c7089bddb84ef0"
SRC_URI = "git://git.linphone.org/cunit.git;nobranch=1"
PV = "git_${SRCREV}"

LIC_FILES_CHKSUM = "file://COPYING;md5=7734aa853b85d6f935466f081490ddbb"
