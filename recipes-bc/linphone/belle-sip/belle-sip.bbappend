FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"

SRC_URI += " file://pc.patch"

