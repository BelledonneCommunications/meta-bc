FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"
SRC_URI += "file://configure.patch"