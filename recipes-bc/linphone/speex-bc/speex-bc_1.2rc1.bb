require speex-bc_1.2rc1.inc

PR = "r1"
SRC_URI = "gitsm://git.linphone.org/speex.git;branch=linphone;protocol=git"

SRCREV = "${AUTOREV}"

LIC_FILES_CHKSUM = "file://COPYING;md5=314649d8ba9dd7045dfb6683f298d0a8"

