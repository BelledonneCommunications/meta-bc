require speex.inc

PR = "r1"
SRC_URI = "gitsm://git.linphone.org/speex.git;branch=linphone;protocol=git"

SRCREV = "caeb73052b1171758acb565e7174a49fbd1427d2"

LIC_FILES_CHKSUM = "file://COPYING;md5=314649d8ba9dd7045dfb6683f298d0a8"

