require srtp.inc

PR = "${INC_PR}.0"

SRCREV = "d79ae95126baa3cec83097469e97525a1d9e2d50"
SRC_URI = "https://gitlab.linphone.org/BC/public/external/srtp.git"
PV = "git_${SRCREV}"

LIC_FILES_CHKSUM = "file://LICENSE;md5=15bc16b9d2e305974dde47e733883714"
